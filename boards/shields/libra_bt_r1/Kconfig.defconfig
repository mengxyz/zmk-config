## boards/shields/libra_bt_r1/Kconfig.defconfig
```kconfig
if SHIELD_LIBRA_BT_R1

config ZMK_KEYBOARD_NAME
    default "Libra BT R1"

endif
```
